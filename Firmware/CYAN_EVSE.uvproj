# Keil uVision project CYAN_EVSE.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: CYAN_EVSE +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c timer.c BspTime.c sys_queue.c dlt645_data.c dlt645.c gpio.c adc.c uart.c pwm.c
