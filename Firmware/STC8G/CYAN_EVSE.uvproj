# Keil uVision project CYAN_EVSE.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K28 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x6FF8) CLOCK(35000000) MODP2
  output: CYAN_EVSE +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Modbus_Master
  group Source Group 1
    ./: main.c timer.c BspTime.c sys_queue.c gpio.c adc.c uart.c pwm.c cp_signal.c s1_switch.c charge_current.c state_task_aim.c watch_dog.c dlt645_data.c dlt645.c delay.c
  group New Group
    ./: adc.h BspTime.h charge_current.h config.h cp_signal.h dlt645.h dlt645_private.h gpio.h pwm.h s1_switch.h state_mech.h STC8xxxx.H sys_queue.h timer.h TYPESS.h uart.h
