# Keil uVision project CYAN_EVSE.uvprojx, settings and files
target PWM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\SYSTEM\bsptime;..\SYSTEM\IM1281B;..\HARDWARE\I2C;..\SYSTEM\delay;..\HARDWARE\OLED;..\HARDWARE\CP_SIGNAL;..\HARDWARE\ADC;..\SYSTEM\state;..\SYSTEM\charge_current;..\SYSTEM\s1_switch;..\SYSTEM\ui;..\HARDWARE\STMFLASH;..\SYSTEM\eeprom;..\HARDWARE\RTC;..\HARDWARE\DS18B20;..\SYSTEM\Ds64RomSearch;..\HARDWARE\WDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c
  group HARDWARE
    ./: main.c system_stm32f10x.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/CP_SIGNAL/: cp_signal.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/WDG/: wdg.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/bsptime/: BspTime.c
    ../SYSTEM/IM1281B/: IM1281B.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/state/: state_task_aim.c
    ../SYSTEM/charge_current/: charge_current.c
    ../SYSTEM/s1_switch/: s1_switch.c
    ../SYSTEM/ui/: ui.c
    ../SYSTEM/eeprom/: eeprom.c
    ../SYSTEM/Ds64RomSearch/: Ds64RomSearch.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_iwdg.c
  group README
    ../: README.TXT
